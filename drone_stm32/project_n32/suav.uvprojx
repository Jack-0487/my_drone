# Keil uVision project suav.uvprojx, settings and files
target SUAV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G430C8Q7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: suav +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER
  c include: ..\firmware\CMSIS\device;..\firmware\n32g430_std_periph_driver\inc;..\firmware\CMSIS\core
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ../firmware/CMSIS/device/startup/: startup_n32g430.s
    ../firmware/CMSIS/device/: system_n32g430.c
  group firmware
    ../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_beeper.c n32g430_can.c n32g430_comp.c n32g430_crc.c n32g430_dbg.c n32g430_dma.c n32g430_exti.c n32g430_flash.c n32g430_gpio.c n32g430_i2c.c n32g430_iwdg.c n32g430_lptim.c n32g430_pwr.c n32g430_rcc.c n32g430_rtc.c n32g430_spi.c n32g430_tim.c n32g430_usart.c n32g430_wwdg.c
  group src
    ../src/: main.c
    ../src/led/: led.c
    ../src/schedule/: ticks.c
    ../src/bus/: uart.c i2c_soft.c
    ../src/iap/: iap.c
  group hardware
    ../src/hardware/: hw_led.c hw_timer.c hw_uart.c hw_i2c_soft.c
  group common
    ../src/common/: fifo.c filter.c mlib.c
  group msp
    ../src/msp/: msp.c
  group ahrs
    ../src/ahrs/: mpu6050.c accgyro.c imu.c alignment.c barometer.c spl06.c altitude.c opflow.c
  group fc
    ../src/fc/: decode.c fc.c pid.c
    ../src/motor/: motor.c
